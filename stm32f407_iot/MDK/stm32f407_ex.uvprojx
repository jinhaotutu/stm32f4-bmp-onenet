# Keil uVision project stm32f407_ex.uvprojx, settings and files
target stm32f4_project (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_ex +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\fwlib\inc;..\sys;..\user;..\misis;..\dev\onenet;..\dev\wifi;..\dev\temp;..\dev\infrared;..\dev\ov7670;..\dev\rgb2bmp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group misis
    ../misis/: system_stm32f4xx.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group sys
    ../sys/: sys_cfg.c sys_delay.c
  group wifi
    ../dev/wifi/: net_device.c net_io.c
  group onenet
    ../dev/onenet/: dStream.c EdpKit.c fault.c onenet.c
  group temp
    ../dev/temp/: SI7021.c
  group infrared
    ../dev/infrared/: infrared.c
  group ov7670
    ../dev/ov7670/: dcmi.c ov7670.c ov7670test.c sccb.c
  group rgb2bmp
    ../dev/rgb2bmp/: rgb2bmp.c
